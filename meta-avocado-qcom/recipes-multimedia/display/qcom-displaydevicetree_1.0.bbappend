FILESEXTRAPATHS:prepend := "${THISDIR}/display-devicetree:"
SRC_URI += "file://0001-delete-ssc.patch"
