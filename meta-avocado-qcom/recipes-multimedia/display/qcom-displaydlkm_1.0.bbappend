SRC_URI = "git://git@github.com/rubikpi-ai/display-drivers;protocol=https;branch=main"
SRCREV = "4be60c18a6e6e911e5982bc02d5687e9053de3d8"

