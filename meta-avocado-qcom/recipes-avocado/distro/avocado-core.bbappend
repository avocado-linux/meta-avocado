# Needed by qcom images
do_compile[depends] += "avocado-image-rootfs:do_deploy_fixup"
