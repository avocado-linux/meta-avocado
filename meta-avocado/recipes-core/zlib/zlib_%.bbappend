# Enable static library builds for qemu-user-static
# This builds libz.a in addition to the shared library
DISABLE_STATIC = ""
