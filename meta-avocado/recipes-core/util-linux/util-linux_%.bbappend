PACKAGECONFIG:append = " blkid uuid"
