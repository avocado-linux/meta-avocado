# Enable static library builds for qemu-user-static
# libpcre2 uses autotools, so DISABLE_STATIC controls --enable-static
DISABLE_STATIC = ""
