ROOTFS_POSTPROCESS_COMMAND:remove = "systemd_sysusers_check"
ROOTFS_POSTPROCESS_COMMAND:remove = "zap_empty_root_password"
