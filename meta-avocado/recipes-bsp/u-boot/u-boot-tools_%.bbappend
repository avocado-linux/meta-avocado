require recipes-bsp/u-boot/u-boot-tools-fit-keytools.inc
