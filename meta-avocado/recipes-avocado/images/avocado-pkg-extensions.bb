DESCRIPTION = "Avocado extensions package image"
LICENSE = "Apache-2.0"

inherit packages-only

IMAGE_INSTALL = "packagegroup-avocado-extensions"
