PACKAGE_ARCH = "${MACHINE_ARCH}"
