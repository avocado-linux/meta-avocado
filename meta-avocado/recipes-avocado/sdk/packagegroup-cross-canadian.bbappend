RDEPENDS:${PN}:remove = "meta-environment-${MACHINE}"
