SUMMARY = "Color manipulation library for Python"
DESCRIPTION = "Colorzero is a color manipulation library for Python. \
It is primarily intended for use with the gpiozero library."
HOMEPAGE = "https://colorzero.readthedocs.io/"
AUTHOR = "Dave Jones <dave@waveform.org.uk>"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ae6c62710c0646f3c60d1ad812ea9bf9"

SRC_URI[sha256sum] = "e7d5a5c26cd0dc37b164ebefc609f388de24f8593b659191e12d85f8f9d5eb58"

inherit pypi python_setuptools_build_meta

