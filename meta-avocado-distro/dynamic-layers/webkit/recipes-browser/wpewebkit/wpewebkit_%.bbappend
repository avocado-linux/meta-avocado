inherit parallel-make-highmem
