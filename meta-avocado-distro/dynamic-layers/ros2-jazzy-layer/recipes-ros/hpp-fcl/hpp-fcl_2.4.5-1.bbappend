SRC_URI:remove = "file://add-missing-boost-include.patch"
SRC_URI:remove = "file://make-cmake-target-relative.patch"
