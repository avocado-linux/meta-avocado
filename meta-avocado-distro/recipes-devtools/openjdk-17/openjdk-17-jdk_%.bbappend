# Enable nativesdk build for OpenJDK 17 JDK
# This allows Java to be included in the Avocado SDK
BBCLASSEXTEND:append = " nativesdk"
