FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

require u-boot-env.inc
