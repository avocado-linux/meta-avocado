# https://git.yoctoproject.org/meta-security/commit/?id=1e4c3ba4c0a83c79de4c95826d4d885704f90d77
BBCLASSEXTEND = "native nativesdk"
