DEPENDS += "rubikpi3-dtbo"
