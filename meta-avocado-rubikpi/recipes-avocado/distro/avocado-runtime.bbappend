RDEPENDS:${PN}:append = " avocado-img-ufs"
