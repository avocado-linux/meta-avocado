FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-only-apply-search-path-logic-to-relative-pathnames.patch"
