BBCLASSEXTEND = "native nativesdk"
INSANE_SKIP:${PN} += "buildpaths"
