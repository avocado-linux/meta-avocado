SRC_URI = "git://git@github.com/ros2-gbp/osqp_vendor-release;${ROS_BRANCH};protocol=https"
