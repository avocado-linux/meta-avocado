RDEPENDS:${PN}:remove = "namosim"
