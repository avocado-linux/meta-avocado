FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append = " file://0001-replace-deprecated-std-iterator-by-defining-required.patch"
