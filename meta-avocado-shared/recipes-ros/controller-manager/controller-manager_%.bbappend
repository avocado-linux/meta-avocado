# Remove obsolete patch that has been applied upstream
SRC_URI:remove = "file://disable-compiler-options.patch"


