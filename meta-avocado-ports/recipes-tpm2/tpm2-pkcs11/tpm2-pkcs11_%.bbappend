# https://git.yoctoproject.org/meta-security/commit/?id=cd729862f68152bc76db02cd4a93ca12a9424f88
BBCLASSEXTEND = "native nativesdk"
