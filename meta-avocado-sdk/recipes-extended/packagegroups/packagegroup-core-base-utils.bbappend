RDEPENDS:${PN}:remove = " \
  e2fsprogs \
  ipupdown \
  dhcpcd \
  kea \
  dpkg-start-stop \
"
