FILESEXTRAPATHS:prepend:avocado-x86-64 := "${THISDIR}/files:"
