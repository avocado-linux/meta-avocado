# See optee-os_%.bbappend for rationale.
PACKAGE_ARCH = "${MACHINE_SOCARCH}"
