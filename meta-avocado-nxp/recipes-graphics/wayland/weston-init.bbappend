FILESEXTRAPATHS:prepend:avocado-imx95-frdm := "${THISDIR}/files/${MACHINE}:"
