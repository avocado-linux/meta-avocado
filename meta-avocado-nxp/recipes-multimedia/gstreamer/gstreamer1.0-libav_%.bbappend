# See gstreamer1.0_%.bbappend in this dir for rationale.
PACKAGE_ARCH = "${MACHINE_SOCARCH}"
