# meta-imx's u-boot-tools fork is the preferred nativesdk-u-boot-tools provider
# on i.MX, so the FIT key tools have to be installed here too.
require recipes-bsp/u-boot/u-boot-tools-fit-keytools.inc
