do_genimage[depends] += "imx-boot:do_deploy"
GENIMAGE_VARIABLES[IMX_BOOT_SEEK] = "${IMX_BOOT_SEEK}"
