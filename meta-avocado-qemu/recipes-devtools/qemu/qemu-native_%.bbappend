DEPENDS:append:qemux86-64 = " ovmf swtpm-native"
