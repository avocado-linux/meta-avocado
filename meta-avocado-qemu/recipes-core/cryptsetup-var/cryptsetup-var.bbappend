FILESEXTRAPATHS:prepend:avocado-qemuarm64 := "${THISDIR}/files:"
FILESEXTRAPATHS:prepend:avocado-qemux86-64 := "${THISDIR}/files:"
