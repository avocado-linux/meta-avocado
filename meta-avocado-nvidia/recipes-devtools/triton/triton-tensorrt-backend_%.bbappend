PACKAGECONFIG = "gpu stats"
