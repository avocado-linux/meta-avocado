# Enable CUDA support for vision-opencv on NVIDIA platforms
inherit cuda


