# Enable CUDA support for cv-bridge on NVIDIA platforms
inherit cuda


