# Removed avocado-img-tegraflash - BSP files now deployed via tegraflash-bsp
