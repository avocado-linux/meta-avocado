IMAGE_TEGRAFLASH_ROOTFS = "${IMGDEPLOYDIR}/${IMAGE_NAME}.${IMAGE_TEGRAFLASH_FS_TYPE}"
